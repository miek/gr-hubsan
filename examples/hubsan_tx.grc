<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hubsan_tx</value></param>
<param><key>author</key><value>Mike Walters</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Based on gr-fsk-burst by Tim O'Shea</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Hubsan Controller</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dev</value></param>
<param><key>value</key><value>186e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>21</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>dev*2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>800e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>samp_rate/data_rate</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>bits_to_symbols</value></param>
<param><key>fn</key><value>lambda x: numpy.array(x, dtype=numpy.float32)*2-1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("FLY")</value></param>
<param><key>period</key><value>10</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>fsk_modulator</value></param>
<param><key>fn</key><value>lambda x: numpy.array(numpy.exp(1j*2*numpy.pi*((dev*x*numpy.arange(len(x)))/samp_rate)),dtype="complex64")</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>fsk_modulator_0</value></param>
<param><key>fn</key><value>lambda x: numpy.tile(x,[sps,1]).T.reshape([1,len(x)*sps])</value></param>
</block>
<block>
<key>hubsan_build_packet_b</key>
<param><key>id</key><value>hubsan_build_packet_b_0</value></param>
<param><key>a7105_id</key><value>1746746778</value></param>
<param><key>sps</key><value>1</value></param>
<param><key>tx_id</key><value>1179779243</value></param>
</block>
<block>
<key>hubsan_joystick_source_f</key>
<param><key>id</key><value>hubsan_joystick_source_f_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>interp</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>bits to syms</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>interp samp/sym</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0_0</value></param>
<param><key>note</key><value>fsk mod</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>30</value></param>
<param><key>freq0</key><value>2.46e9</value></param>
<param><key>if_gain0</key><value>30</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate*interp</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pyqt_cpsd_plot</key>
<param><key>id</key><value>pyqt_cpsd_plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value></value></param>
</block>
<block>
<key>pyqt_time_plot</key>
<param><key>id</key><value>pyqt_time_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value></value></param>
<param><key>style</key><value>line</value></param>
</block>
<connection><source_block_id>bits_to_symbols</source_block_id><sink_block_id>fsk_modulator_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>bits_to_symbols</source_block_id><sink_block_id>pyqt_time_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>hubsan_build_packet_b_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fsk_modulator</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>pdus</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>fsk_modulator</source_block_id><sink_block_id>pyqt_cpsd_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>fsk_modulator</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>fsk_modulator_0</source_block_id><sink_block_id>fsk_modulator</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hubsan_build_packet_b_0</source_block_id><sink_block_id>bits_to_symbols</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>hubsan_joystick_source_f_0</source_block_id><sink_block_id>hubsan_build_packet_b_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
